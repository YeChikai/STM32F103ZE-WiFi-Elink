# Keil uVision project iSO-STM32.uvprojx, settings and files
target WF-ESP8266 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WIFI_ePaper +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\Driver;..\..\Driver\beep;..\..\Driver\dht11;..\..\Driver\esp8266;..\..\Driver\systick;..\..\Driver\usart;..\..\Driver\led;..\..\Driver\gpio;..\..\Driver\spi;..\..\Driver\elink042t2;..\..\Hall;..\..\Hall\HallCommon;..\..\Hall\HallWIFI;..\..\Hall\HallDisplay;..\..\App;..\..\App\Data;..\..\Driver\fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group DOC
    ../../Doc/: readme.txt
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group APP
    ../../App/: main.c
  group HALL
    ../../Hall/HallCommon/: HallCommon.c
    ../../Hall/HallWIFI/: HallWIFI.c
    ../../Hall/HallDisplay/: HallDisplay.c
  group DRIVER
    ../../Driver/: stm32f10x_it.c
    ../../Driver/beep/: bsp_beep.c
    ../../Driver/esp8266/: bsp_esp8266.c
    ../../Driver/dht11/: bsp_dht11.c
    ../../Driver/gpio/: bsp_gpio.c
    ../../Driver/led/: bsp_led.c
    ../../Driver/systick/: bsp_SysTick.c
    ../../Driver/usart/: bsp_usart1.c
    ../../Driver/spi/: bsp_spi.c
    ../../Driver/elink042t2/: bsp_elink.c
    ../../Driver/fatfs/: fatfs_flash_spi.c
software components: CMSIS:CORE 4.1.0
